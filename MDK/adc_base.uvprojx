# Keil uVision project adc_base.uvprojx, settings and files
target adc_base_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_base +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __CC_ARM
  c include: ..\source;..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\drivers\cmsis\Include;..\drivers\hc32_ll_driver\inc;..\drivers\bsp\ev_hc32f460_lqfp100_v2;..\bsp\net;..\bsp\rtc;..\bsp\GPS;..\bsp\led_beep;..\bsp\timers;..\bsp\bsp_driver\usart;..\bsp\common;..\bsp\flash;..\bsp\stack;..\bsp\bsp_driver\gpio;..\bsp\bsp_driver\adc;..\bsp\power;..\bsp\bsp_driver\i2c;..\bsp\RX8025T;..\bsp\fmath;..\bsp\bsp_driver\icm20689;..\bsp\INS;..\bsp\imu;..\bsp\dsp;..\bsp\data_buf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_dma.c hc32_ll_rtc.c hc32_ll_aos.c hc32_ll_i2c.c hc32_ll_spi.c
  group ev_hc32f460_lqfp100_v2
    ../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group Readme
    ../: Readme.txt
  group net
    ../bsp/net/: net_thread.c
  group GPS
    ../bsp/GPS/: gps_thread.c gps_port.c
  group RTC
    ../bsp/rtc/: rtc_thread.c rtc_port.c
  group led&beep
    ../bsp/led_beep/: led_beep_thread.c beep_port.c led_port.c led_function.c
  group bsp_driver
    ../bsp/timers/: timer.c
    ../bsp/bsp_driver/usart/: usart.c
    ../bsp/bsp_driver/gpio/: gpio.c
    ../bsp/bsp_driver/adc/: adc.c
    ../bsp/bsp_driver/i2c/: bsp_i2c.c
    ../bsp/bsp_driver/icm20689/: icm20689.c
  group common
    ../bsp/common/: common_c.c
  group flash
    ../bsp/flash/: flash_port.c flash_function.c
  group stack
    ../bsp/stack/: stack.c
  group power
    ../bsp/power/: power_port.c
  group rx8025t
    ../bsp/RX8025T/: RX8025T.c
  group fmath
    ../bsp/fmath/: arm_cos_f32.c arm_sin_f32.c fmath.c lpf.c
  group ins
    ../bsp/INS/: ins.c
  group imu
    ../bsp/imu/: imu.c
  group DSP
    ../bsp/dsp/: arm_mat_add_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group data_buf
    ../bsp/data_buf/: data_buf.c
target adc_base_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: adc_base +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0
